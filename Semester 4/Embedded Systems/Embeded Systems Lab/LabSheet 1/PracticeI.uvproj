# Keil uVision project PracticeI.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI) EBIG
  output: PracticeI
  c flags: Optim=1
  group Source Group 1
    ./: Q1.asm
  group New Group
    ./: p7.ASM
