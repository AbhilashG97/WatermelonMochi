# Keil uVision project LabSheet1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI) EBIG
  output: LabSheet1
  c flags: Optim=1
  group Source Group 1
    ./: P1.asm P3.asm
  group New Group
    ./: P2.asm
